v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/code.sym} -150 -60 0 0 {name=COMMANDS
simulator=ngspice
only_toplevel=false
value="
* ngspice commands
.include corner.spi
"}
